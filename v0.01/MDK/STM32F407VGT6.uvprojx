# Keil uVision project STM32F407VGT6.uvprojx, settings and files
target STM32G407VGT6 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32G40VGT6 +hex
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, USE_FULL_ASSERT, USE_USB_OTG_FS, DEBUG1, DEBUG0
  c include: ..\inc;..\Libraries\CMSIS\Include;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Utilities\STM32_EVAL;..\Libraries\Device\STM32F4xx\Include;..\src;..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: pid.c main.c usb_bsp.c general.c ledRing.c interface.c retarget.c joyStick.c
  group periph
    ../src/: system_stm32f4xx.c stm32f4xx_it.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_gpio.c misc.c stm32f4xx_syscfg.c stm32f4xx_spi.c
    ../Libraries/Device/STM32F4xx/Include/: stm32f4xx.h
  group usb_host
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group usb_class
    ../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group Utilities
    ../Utilities/STM32_EVAL/: stm32f4_discovery.c
  group Startup
    ../src/: startup_stm32f4xx.s
  group Car
    ../src/: steering.c motorControl.c car.c
  group Coms
    ../src/: ESP8266.c serie3.c serie1.c serie2.c nRF24L01P.c
  group Sensors
    ../src/: usbh_usr.c IRSensors.c Accelerometer.c
